# Keil uVision project keiltestblinky.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: keiltestblinky +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: maiin.c
  group ::Device
    RTE/Device/STM32F405RG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.6/Device/StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_tim.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.6/RTE_Driver/: GPIO_STM32F4xx.c
software components: CMSIS:CORE 3.20.0, Device:GPIO 1.0.0, Device:Startup 1.3.0, Device:StdPeriph Drivers:Framework 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0
